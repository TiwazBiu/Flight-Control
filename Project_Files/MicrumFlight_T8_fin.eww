<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ucOS3_TM4C123.ewp</path>
    </project>
    <batchBuild />
</workspace>
