# IAR project ucOS3_TM4C123.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_BLIZZARD_RB1
  ICCARM.CCIncludePath2: ..\uCOS-III\UCOSIII\Source; ..\uCOS-III\UCOSIII\Ports; ..\uCOS-III\UCOSIII_BSP; ..\uCOS-III\UCOSIII_CONFIG; ..\uCOS-III\UCOSIII_CPU; ..\uCOS-III\UCOSIII_CPU\ARM-Cortex-M4\IAR; ..\uCOS-III\UCOSIII_LIB; ..\Generic_Lib; ..\Generic_Lib\board; ..\Generic_Lib\chip; ..\Generic_Lib\peripheral; ..\Core_Code; ..\Core_Code\HARDWARE; ..\Generic_Lib\app; ..\Generic_Lib\app\openpilot; ..\Generic_Lib\app\openpilot\Data; ..\Generic_Lib\app\openpilot\math; ..\Generic_Lib\app\openpilot\Param
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ucOS3_TM4C123.srec
  ILINK.IlinkOutputFile: ucOS3_TM4C123.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group HARDWARE
    ../Core_Code/HARDWARE/: core_camera.c core_uart.c
  group TIVA_LIB/TIVA_PERIPHERAL
    ../Generic_Lib/peripheral/driverlib/: adc.c can.c comp.c cpu.c eeprom.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c mpu.c pwm.c qei.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group UCOSIII_BSP
    ../uCOS-III/UCOSIII_BSP/: bsp.c bsp_int.c bsp_sys.c cpu_bsp.c
  group UCOSIII_BSP/STARTUP
    ../uCOS-III/UCOSIII_BSP/IAR/: project.icf startup_ewarm.c
  group UCOSIII_CONFIG
    ../uCOS-III/UCOSIII_CONFIG/: app_cfg.h bsp_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group UCOSIII_CORE
    ../uCOS-III/UCOSIII/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group UCOSIII_CPU
    ../uCOS-III/UCOSIII_CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_a.asm cpu_c.c
    ../uCOS-III/UCOSIII_CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group UCOSIII_LIB
    ../uCOS-III/UCOSIII_LIB/: lib_ascii.c lib_def.h lib_math.c lib_mem.c lib_str.c
    ../uCOS-III/UCOSIII_LIB/Ports/: lib_mem_a.asm
  group UCOSIII_PORT
    ../uCOS-III/UCOSIII/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group USER
    ../Core_Code/: core_main.c
  group USER/APP
    ../Generic_Lib/app/: IRQ_handler.c
    ../Generic_Lib/app/openpilot/: virtualflybar.c
  group USER/APP/OpenPilot
    ../Generic_Lib/app/openpilot/: attitudesolving.c control_command.c data_common.c data_transfer.c hold.c mixer.c motor_control.c param_common.c Postion_Hold.c relay_tuning.c sensorfetch.c stabilization.c
    ../Generic_Lib/app/openpilot/Param/: eepromqsj.c
  group USER/APP/OpenPilot/Data
    ../Generic_Lib/app/openpilot/Data/: acceldesired.c accels.c accessorydesired.c actuatorcommand.c actuatordesired.c attitudeactual.c attitudesensor.c flightbatterystate.c flightstatus.c gyros.c gyrosbias.c manualcontrolcommand.c mixerstatus.c nrf_data.c ratedesired.c relaytuning.c stabilizationdesired.c state_struct.c timestamp.c trimangles.c uart_data.c
  group USER/APP/OpenPilot/Math
    ../Generic_Lib/app/openpilot/math/: atmospheric_math.c coordinate_conversions.c misc_math.c pid.c sin_lookup.c
  group USER/APP/OpenPilot/Param
    ../Generic_Lib/app/openpilot/Param/: actuatorsettings.c attitudesettings.c manualcontrolsettings.c mixersettings.c motorsettings.c relaytuningsettings.c sensorsettings.c stabilizationsettings.c systemsettings.c
  group USER/Board
    ../Generic_Lib/board/: core_uartstdio.c KS103.c PX4Flow.c YRK_AK8975_SOFT.c YRK_init.c YRK_LED.c YRK_MPU6050_SOFT.c YRK_NRF24L0.c YRK_SONAR.c
  group USER/Chip
    ../Generic_Lib/chip/: common.c
